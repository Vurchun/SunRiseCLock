# Keil uVision project CMSIS_LED_DYN.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS_LED_DYN +hex
  AfterMake: fromelf --bin --output .\Objects\CMSIS_LED_DYN.bin .\Objects\CMSIS_LED_DYN.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,STM32F10X_MD
  c include: .\user\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/src/: main.c led.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
